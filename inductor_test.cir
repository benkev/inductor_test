* C:\Users\benkev\Kicad\Projects\inductor_test\inductor_test.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 7/12/2017 11:39:39 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U3  Net-_CON1-Pad5_ Net-_U3-Pad2_ Net-_U3-Pad3_ GND Net-_CON1-Pad1_ Net-_CON1-Pad9_ Net-_CON1-Pad7_ +5V ATTINY13A-PU
U4  Net-_C4-Pad1_ Net-_CON1-Pad1_ Net-_C5-Pad1_ Net-_U3-Pad2_ Net-_C6-Pad1_ Net-_CON1-Pad7_ GND Net-_U3-Pad3_ Net-_C3-Pad1_ +5V 74HC14
CON1  Net-_CON1-Pad1_ +5V ? GND Net-_CON1-Pad5_ GND Net-_CON1-Pad7_ GND Net-_CON1-Pad9_ GND AVR-ISP-10
SW1  Net-_R4-Pad1_ GND Net-_R5-Pad1_ Net-_R3-Pad1_ GND RotEncoder
Q1  GND Net-_JP1-Pad2_ Net-_Q1-Pad3_ 2N7000
Q2  GND Net-_Q1-Pad3_ Net-_Q2-Pad3_ 2N7000
Q4  GND Net-_Q2-Pad3_ Net-_Q3-Pad1_ 2N2222A
Q3  Net-_Q3-Pad1_ Net-_Q2-Pad3_ /15V 2N2906
J1  /Vin Net-_J1-Pad2_ GND DC_JACK
P2  /Vin Net-_D1-Pad2_ CONN_2
Q5  Net-_Q3-Pad1_ Net-_D1-Pad2_ Net-_P3-Pad1_ IRLIZ24N
C7  /Vin GND 0.33uF
C8  /15V GND 1uF
C1  /Vin GND 100nF
C2  +5V GND 1uF
R1  Net-_J1-Pad2_ /Vin 1M
R10  /15V Net-_Q1-Pad3_ 1k
R11  /15V Net-_Q2-Pad3_ 1k
R12  Net-_P3-Pad1_ GND 0.1
C9  /Vin GND 4700uF
D1  /Vin Net-_D1-Pad2_ SF28
C6  Net-_C6-Pad1_ GND 10n
C5  Net-_C5-Pad1_ GND 10n
C4  Net-_C4-Pad1_ GND 10n
R4  Net-_R4-Pad1_ Net-_C5-Pad1_ 3k3
R5  Net-_R5-Pad1_ Net-_C6-Pad1_ 3k3
R3  Net-_R3-Pad1_ Net-_C4-Pad1_ 3k3
R7  +5V Net-_R4-Pad1_ 33k
R8  +5V Net-_R3-Pad1_ 33k
R6  +5V Net-_R5-Pad1_ 33k
JP1  Net-_CON1-Pad9_ Net-_JP1-Pad2_ Net-_JP1-Pad3_ Jumper_NC_Dual
P1  Net-_JP1-Pad3_ Net-_JP1-Pad3_ ? GND CONN_4
C10  /Vin GND .47uF
C11  /Vin GND 47pF
P3  Net-_P3-Pad1_ Net-_P3-Pad1_ ? GND CONN_4
SW2  Net-_R2-Pad2_ GND SW_Push
C3  Net-_C3-Pad1_ GND 10n
R2  Net-_C3-Pad1_ Net-_R2-Pad2_ 3k3
R9  +5V Net-_R2-Pad2_ 33k
U1  GND /Vin +5V 78L05
U2  GND /Vin /15V 78L05

.end
